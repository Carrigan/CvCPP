# Keil uVision project Morse.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Morse
  c flags: Optim=1
  c include: .\Source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./Source/: system_MKL25Z4.c startup_MKL25Z4.s
  group Source
    ./Source/: GPIO.c LED_rgb.c main.c MorseCodeMessenger.c system_MKL25Z4.c Timer.c
  group Headers
    ./Source/: MemMapPtr_KL25Z4.h MKL25Z4.h MKL25Z4_CMSIS.h
